# Keil uVision project LightCtrl.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L053C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LightCtrl +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\HAL_DRIVER\Inc;..\LIB;..\source;..\include;..\Libc\inc;..\usart_console;..\PresystemInit;..\LIB;..\trf796xx;..\Timer;..\spi;..\cc110x;..\CommentHeader;..\DeviceManagement;..\Resource;..\LED;..\Adc;..\Sysmode
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group HAL_DRIVER
    ../HAL_DRIVER/Src/: stm32l0xx_hal.c stm32l0xx_hal_uart.c stm32l0xx_hal_rcc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_usart.c stm32l0xx_hal_cortex.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c
  group libs
    ../LIB/: stm32l0x56.lib
  group source
    ../source/: main.c stm32l0xx_it.c
  group usart_console
    ../usart_console/: com_uart.c lpuart.c stm_console.c console_cmd.c
  group PresysremInit
    ../PresystemInit/: system.c
  group trf796xx
    ../trf796xx/: trf796xx_adapter.c trf796xx_module.c check_out_card.c
  group lite_timer
    ../Timer/: lite_timer.c
  group cc110x
    ../cc110x/: cc110x_adapter.c cc110x_module.c cc110x_hal.c spi_com.c
  group DeviceManagement
    ../DeviceManagement/: device_handle_data.c device_info.c device_mangement.c device_pakage.c
  group DeviceResource
    ../Resource/: LiteMasterResource.c
  group LED
    ../LED/: led.c
  group module_comm
    ../CommentHeader/: module_common.c
  group Adc
    ../Adc/: adc.c
  group Sysmode
    ../Sysmode/: sysmode.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.6.0
